<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usblib\usblib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_io\enet_io.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_lwip\enet_lwip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_uip\enet_uip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_weather\enet_weather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hibernate\hibernate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs_iot\qs_iot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sleep_modes\sleep_modes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_cserial\usb_dev_cserial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard\usb_dev_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_io</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_lwip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_uip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_weather</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hibernate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs_iot</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sleep_modes</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_cserial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
