<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\grlib\grlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usblib\usblib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo1\boot_demo1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo2\boot_demo2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_serial\boot_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_usb\boot_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hibernate\hibernate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-logger\qs-logger.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sine_demo\sine_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\softuart_echo\softuart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard\usb_dev_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_msc\usb_dev_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_serial\usb_dev_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_audio\usb_host_audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hibernate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-logger</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sine_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>softuart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_audio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
