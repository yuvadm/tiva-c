<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usblib\usblib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\freertos_demo\freertos_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\project0\project0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-rgb\qs-rgb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_gamepad\usb_dev_gamepad.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_serial\usb_dev_serial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freertos_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>project0</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-rgb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_gamepad</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
