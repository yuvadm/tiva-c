<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\grlib\grlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usblib\usblib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_cbc_decrypt\aes_cbc_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_cbc_encrypt\aes_cbc_encrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ccm_decrypt\aes_ccm_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ccm_encrypt\aes_ccm_encrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_cmac\aes_cmac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ecb_decrypt\aes_ecb_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ecb_encrypt\aes_ecb_encrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_gcm_decrypt\aes_gcm_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_gcm_encrypt\aes_gcm_encrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ble_btool\ble_btool.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ble_central\ble_central.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_uart\boot_demo_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_usb\boot_demo_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_emac_flash\boot_demo_emac_flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_flash\boot_demo_flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_emac_flash\boot_emac_flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\calibrate\calibrate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\crc32\crc32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_io\enet_io.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_lwip\enet_lwip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_uip\enet_uip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fontview\fontview.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\freertos_demo\freertos_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib_demo\grlib_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib_driver_test\grlib_driver_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello_widget\hello_widget.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hibernate\hibernate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lang_demo\lang_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs_weather\qs_weather.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\scribble\scribble.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sha1_hash\sha1_hash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sha1_hmac\sha1_hmac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\synth\synth.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tamper\tamper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tdes_cbc_decrypt\tdes_cbc_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tdes_cbc_encrypt\tdes_cbc_encrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_chid\usb_dev_chid.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_gamepad\usb_dev_gamepad.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard\usb_dev_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_msc\usb_dev_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_serial\usb_dev_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_audio\usb_host_audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_audio_in\usb_host_audio_in.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_hub\usb_host_hub.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_otg_mouse\usb_otg_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_cbc_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_cbc_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_ccm_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_ccm_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_cmac</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_ecb_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_ecb_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_gcm_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_gcm_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ble_btool</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ble_central</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_uart</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_emac_flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_emac_flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>calibrate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>crc32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_io</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_lwip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_uip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fontview</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freertos_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_driver_test</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello_widget</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hibernate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lang_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs_weather</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>scribble</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sha1_hash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sha1_hmac</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>synth</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tamper</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tdes_cbc_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tdes_cbc_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_chid</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_gamepad</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_audio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_audio_in</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_hub</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_otg_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
