# IAR project sensorlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1230C3PM TexasInstruments TM4C1230C3PM
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: sensorlib.srec
  ILINK.IlinkOutputFile: sensorlib.out
  group Source
    ./: ak8963.c ak8975.c bmp180.c bq27510g3.c cm3218.c comp_dcm.c i2cm_drv.c isl29023.c kxti9.c l3gd20h.c lsm303d.c lsm303dlhc_accel.c lsm303dlhc_mag.c magneto.c mpu6050.c mpu9150.c quaternion.c sht21.c tmp006.c tmp100.c vector.c
